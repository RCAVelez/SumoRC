Commit message: modified arena size

File: simulation/resources/sumoarenamodel.urdf (robot description, URDF)
Before this commit: robot simpleplane, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=arena.STL; visual mesh filename=arena.STL
